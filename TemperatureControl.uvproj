# Keil uVision project TemperatureControl.uvproj, settings and files
target TemperatureControl (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: TemperatureControl +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c button.h
